options:
  parameters:
    generate_options: qt_gui
    id: Check1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: time_mod
  id: variable
  parameters:
    value: '1e-3'
  states: {}
- name: ProjectBlocks_PWDemodulator_0
  id: ProjectBlocks_PWDemodulator
  parameters:
    Fs: samp_rate
    sensetivity: '0.9'
    t: time_mod
    timeout: '5'
  states: {}
- name: ProjectBlocks_PWModulator_0
  id: ProjectBlocks_PWModulator
  parameters:
    Fs: samp_rate
    msg: Bbcdefghijklmn
    t: time_mod
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/sdr/Documents/SDR/Project/data.bin
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}

connections:
- [ProjectBlocks_PWModulator_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', ProjectBlocks_PWDemodulator_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
